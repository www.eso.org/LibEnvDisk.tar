idim3 [1=3D,sonst axial]: ibug iblack [1: Qabs=1,Qsca=0]
0 1 0
structure: 7 2phase_torus
14
number parameter:
9
1.78998e-23
100
0.
-1
0
1
0
0
2.
iQuelle 2=any LQuelle Tstar distpc nzyk1000
2 3.85d44 10d3 50e6 15000
dGW Rinner Router kugelsym
-999 7.715d17 -999 1
nx ny nz 5 135 135
51 51 51
Dust size distribution: lac lec lasi lesi
6 10 7 12
Dust type jmrn 0=aCSi 1=fluffy
1
anisotropic scattering i_iso 0=gfa 1=HG 2=iso
0
Mit jpah jvsg jgas
0 0 0
PAH: zcpah hydpah abuPAH 0.1 abuVSG 0
100 0.25 0.125d-20 0.1d-15
klump yes=1 nklump 1000 - Zahl der Klumpen
0 1000
oldrandom 0=new,1=old Method 0=BW
0 0
