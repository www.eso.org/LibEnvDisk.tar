idim3 (1=3D,sonst axial):  ibug    iblack (1=>Qabs=1,Qsca=0)
       0                   1      0
structure 1(sphere) 2(disk) 3(clumpy torus) 4(scheibe.f)
	  3
number parameter: 2 (sphere), 3 (torus and hydro.disk), etc.
5
0
1
0.5
5d-5
4
iQuelle [0=Stern,1=AGN,2=any]; LQuelle  Tstar   dist[pc]  nzyk(1000)
         0                     3.85d33   10d3     50.       100000
dGW      Rinner   Router   kugelsym (Dichte absschneiden bei Rout)          
1.5d15   4.5d15     4.5d16   1
Dust size distribution: lac lec lasi lesi (MRN:6 9 7 10)
	6 9  10 10
Dust type jmrn (0 = mrn, 1 = fluffy, 2 = xrays)
    0
anisotropic scattering i_iso (0 = no, 1 = H-G fn, 2 = H-G fn w/ g=0)
0
Mit jpah jvsg jgas (0=no, 1=yes)             
    0    0    0   
PAHs: zcpah; hydpah[~2.8/sqrt(Nc)]; abuPAH (0.1), abuVSG (0)
      150    0.25                    0.125           0.1d-15    
klump (yes=1)  nklump (1000)- Zahl der Klumpensp
        1     	150
oldrandom (0=new, 1=old), Method ( (0=B&W, iter_luci=30) 
	  0               0
