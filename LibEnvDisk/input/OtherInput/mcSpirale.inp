idim3 =1 ist 3dim fall sonst 2dim
       1
structure 1(sphere) 2(disk) 3(clumpy torus) 4(scheibe.f)
	  2
number parameter: 2 (sphere), 3 (torus and hydro.disk), etc.
5
1.2d-18
0.0
0.0
0.0
0.0
LQuelle 3.85d33
        7.7d33
Tstar
	4d3
dist [pc]
        50.
kugelsym der dichte verteilung (absschneiden mit Rout)     
   	1
klump
        0
nklump - Zahl der Klumpensp
      	1000
ibug    iblack=1 ->Qabs=1,Qsca=0)
2       0
nzyk  (< 116400)
	100
iQuelle	[0=Stern,1=AGN,2=any]
	 0
iexpGW1        
	3
dGW = laenge GW 7.48d13
     1.5d13
jhaufen            
    	0
N_Sterne	
	10
L_Haufen	
	3.85d33
T_haufen	
	20d3
LAC Dust size distribution for MRN:6
	6    
LEC Dust size distribution for MRN:9 
	6    
LASI Dust size distribution for MRN:7 
	7    
LESI Dust size distribution for MRN:10
	7    
qmrn	
	3.5
abuc    2d-4   
 	2d-4     
abusi	
	3.1d-5
jvsg             
     	0           
jpah	
	0
jgas
	1
material	
	0
abuvsg                        
   	0.1d-15    
abupah	
	0.1         
zcpah	
	100       
fevap	
	1d-8     
hydpah	
	0.20             
RminPAH  RmaxPAH	
3.d10    7.5d30
Rinner   Router
1.5d13   1.5d14
oldrandom 0 new 1 old random generater
	  0
number iterations for CUDA
          0
size of precalculated data (default=30000) for CUDA
     0000
