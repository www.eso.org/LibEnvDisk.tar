idim3 (1=3D,sonst axial):  ibug    iblack (1=>Qabs=1,Qsca=0)
       0                   0      0
structure 1(sphere) 2(disk) 3(clumpy torus) 4(scheibe.f)
	  1
number parameter: 2 (sphere), 3 (torus and hydro.disk), etc.
3
1e-18     
0.
1
iQuelle [0=Stern,1=AGN,2=any]; LQuelle  Tstar   dist[pc]  nzyk(1000)
         0                     7.7d33   4d3     50.       10
dGW      Rinner   Router   kugelsym (Dichte absschneiden bei Rout)          
1d13     1.5d13   1.5d14   1
Dust size distribution: lac lec lasi lesi (MRN:6 9 7 10)
	6   9 7 10 
Mit jpah jvsg jgas (0=no, 1=yes)             
    0    0    0   
PAHs: zcpah; hydpah[~2.8/sqrt(Nc)]; abuPAH (0.1), abuVSG (0)
      150    0.25                    0.125           0.1d-15    
klump (yes=1)  nklump (1000)- Zahl der Klumpensp
        0     	0
oldrandom (0=new, 1=old), Method ( (0=B&W, iter_luci=30) 
	  0               0
