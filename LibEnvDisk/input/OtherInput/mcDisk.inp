idim3 =1 ist 3dim fall sonst 2dim
       1
a1r: (Dichte:  N  = A  /  Radius**X) 1d-7
       8.1893190e-22
x1r 0.75d0  ! in disk case if  x1r ne 0 then SPIRALE
       5.
LQuelle 3.85d33
        3.85d33
Tstar
	5.8d3
dist [pc]
        150.
kugelsym der dichte verteilung (absschneiden mit Rout)     
   	1
klump
        0
nklump - Zahl der Klumpensp
      	1000
ibug           
  	2
nzyk	
	2000
iQuelle	[0=Stern,1=AGN,2=any]
	 0
iexpGW1        
	6
dGW = länge GW	
	4.61538e14
jhaufen            
    	0
N_Sterne	
	10
L_Haufen	
	3.85d33
T_haufen	
	20d3
LAC Dust size distribution for MRN:6
	6    
LEC Dust size distribution for MRN:9 
	9    
LASI Dust size distribution for MRN:7 
	7    
LESI Dust size distribution for MRN:10
	10    
qmrn	
	3.5
abuc    2d-4   
 	2d-4     
abusi	
	3.1d-5
jvsg             
     	0           
jpah	
	0
material	
	0
abuvsg                        
   	0.1d-15    
abupah	
	0.1          
zcpah	
	100       
fevap	
	1d-8     
hydpah	
	0.20             
RminPAH  RmaxPAH	
1.5e13  1.5e16
Rinner  Router
1.5d13  1.5d16
oldrandom 0 new 1 old random generater
	  0
number iterations for CUDA
          0
size of precalculated data (default=30000) for CUDA
     0000
