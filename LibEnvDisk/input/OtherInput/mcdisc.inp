idim3 (1=3D,sonst axial):  ibug    iblack (1=>Qabs=1,Qsca=0)
       0                   1      0
structure 1(sphere) 2(disk) 3(clumpy torus) 4(scheibe.f)
	  4
number parameter: 2 (sphere), 3 (torus and hydro.disk), etc.
6
1e4    
4.5
40.d33  !2
1.e-30
1           !   55     15
1.4d-98
iQuelle [0=Stern,1=AGN,2=any]; LQuelle  Tstar   dist[pc]  nzyk(1000)
         0                     2d38   33d3     146.       1000
dGW      Rinner   Router   kugelsym (Dichte absschneiden bei Rout)          
4d14     3d16     5d16   1
nx      ny      nz
125	125	50
Dust size distribution: lac lec lasi lesi (MRN:6 9 7 10)
	7    17  1 1 
Dust type jmrn (0 = mrn, 1 = fluffy, 2 = xrays)
    1
anisotropic scattering i_iso (0 = no, 1 = H-G fn, 2 = H-G fn w/ g=0)
0
write out scatters? (1 = yes)
0
Mit jpah jvsg jgas (0=no, 1=yes)             
    0    0    0   
PAHs: zcpah; hydpah[~2.8/sqrt(Nc)]; abuPAH (0.1), abuVSG (0)
      150    0.25                   0.125           0.1d-15    
klump (yes=1)  nklump (1000)- Zahl der Klumpensp
        0     	0
oldrandom (0=new, 1=old), Method ( (0=B&W, iter_luci=30) 
	  0               0
