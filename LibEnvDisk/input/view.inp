naxes1, 2  2048 2048 
128 128  
tau_max 
15. 
theta (0=Draufsicht), Phi [deg] 
30. 0.  
nsubpixel 8  
8 
sel_fr start_fr end_fr : >0 alle, <0 von start bis end_fre (104:11.3; 121:7.7; 181-182: ~1) 
168
14 25      
read in scattering? 
1 
number Blocks (cuda) 0--> auto 
128 
number Grids*Multi Processor (cuda) 0--> 32*number MultiProcessor 
16 
